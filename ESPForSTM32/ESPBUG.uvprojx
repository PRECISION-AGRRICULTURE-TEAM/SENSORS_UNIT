# Keil uVision project ESPBUG.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: ESPBUG
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Source Group 1
    ./: main.c startup_stm32f10x_md.s
    ./SRC/ADC/: ADC.c ADC.h ADC_CFG.h ADC_LOCAL.h
    ./SRC/APP/: APP.c APP.h APP_CFG.h APP_LOCAL.h
    ./SRC/COMMON/: Std_Types.h Utils.h
    ./SRC/DHT11/: DHT11.c
    ./SRC/GPIO/: GPIO.c
    ./SRC/MOISTURE/: MOISTURE.c
    ./SRC/SCHEDULER/: SCHEDULER.c
    ./SRC/SOIL_TEMP/: SOIL_TEMP.c
    ./SRC/TIMER/: TIMER.c
    ./SRC/UART/: UART.c
    ./SRC/ESP8266/: ESP8266.c
